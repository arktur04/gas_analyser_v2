# IAR project GettingStarted.ewp, settings and files
configuration RAM Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  ICCARM.CCDefines: IAR_LPC_1768_SK
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config\LPC1768_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR_LPC_1768_SK; FLASH_LPC1768
  OBJCOPY.OOCOutputFile: GettingStarted.srec
  ILINK.IlinkIcfFile: config\LPC1768_Flash.icf
  group (top)
    ./: adc_fsm.c adc_fsm.h ai_test.cpp ai_test.h ao_test.cpp ao_test.h arm_comm.h bmps.c bmps.h board.c board.h buttons.c buttons.h checkbox.c checkbox.h cstartup_M.s current_outs.c current_outs.h dict.c dict.h disconnect.c disconnect.h do_test.cpp do_test.h editor_scr.cpp editor_scr.h ethernet_scr.cpp ethernet_scr.h font.c font.h irq.c irq.h keyb.c keyb.h lcd.c lcd.h lcd_control.c lcd_control.h lcd_low_level.c lcd_low_level.h led_control.c led_control.h LPC_Uart.c LPC_Uart.h lut_scr.cpp lut_scr.h main.cpp main_scr.cpp main_scr.h menu_scr.cpp menu_scr.h messages.c messages.h misc_scr.cpp misc_scr.h modbus.c modbus.h msg_scr.cpp msg_scr.h param_scr.cpp param_scr.h pass_aux_base_class.cpp pass_aux_base_class.h pass_controller.c pass_controller.h pass_scr.cpp pass_scr.h power_control.c power_control.h processing.cpp processing.h pwm_test.cpp pwm_test.h relay_control.c relay_control.h rs232_scr.cpp rs232_scr.h rs485_scr.cpp rs485_scr.h screens.c screens.h tagvaluelabel.cpp tagvaluelabel.h thermocouple.c thermocouple.h timers.c timers.h trend_scr.cpp trend_scr.h twocolscr.cpp twocolscr.h type.h usbase.cpp usbase.h ustype.h variables.c variables.h
